# Autodesk Inventor part: Fig-1432-PF_28mm
## iProperties
Created: 2011-08
Part Number: Fig-1432-PF_28mm
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
